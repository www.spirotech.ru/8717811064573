Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro 23.0 GLT_INT-EN.ifc
Time: 2025-08-05T18:29:26+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (3)
Description: Flow
Name | FlowDirection | PredefinedType
InPort_2040806_1 | SINK | PIPE
OutPort_2040806_2 | SOURCE | PIPE
Port_2040806_3 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL

# IfcValve: HC_Control Unit_MEPcontent_Spirotech_SpiroPure_GLT Module_INT-EN_Shared:GLT Module, HC_Control Unit_MEPcontent_Spirotech_SpiroPure_GLT Module_INT-EN_Shared:GLT Module:2040807
In: F00
Type - Material: Color RGB 150-150-150, Color RGB 200-200-200, Color RGB 000-128-255
Type - Other - Category: Pipe Accessories; Family Name: HC_Control Unit_MEPcontent_Spirotech_SpiroPure_GLT Module_INT-EN_Shared
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 59 mm; Height: 122 mm; Width: 120 mm
Type - Identity Data - Custom: no; Article Description: GLT Module for SpiroPure Pro; Article Type: GLT Module; Base Family Version: 24.10; Content Supplier URL: www.MEPcontent.com; Copyright: ©Trimble Europe BV; Description: GLT Module for SpiroPure Pro; EMCS Version: 5.0; ETIM Article Class: EC004571; Family Version: 24.10; GLN: 8717811000007; Manufacturer: Spirotech; Manufacturer URL: https://www.spirotech.com/products/spiropure/; MEPcontent Class: CONTROL_UNIT_HC; Model: GLT Module; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Product Line: SpiroPure; Revit Version: 2022; Type Name: GLT Module; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Blue: Color RGB 000-128-255; Grey: Color RGB 150-150-150; White: Color RGB 200-200-200
Type - Mechanical - Weight: 0.6 kg
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: GLT Module; sets with these values: 2
Other - Family: HC_Control Unit_MEPcontent_Spirotech_SpiroPure_GLT Module_INT-EN_Shared; Family and Type: HC_Control Unit_MEPcontent_Spirotech_SpiroPure_GLT Module_INT-EN_Shared: GLT Module; Type: GLT Module; Type Id: 2040685
Constraints - Elevation from Level: 246 mm; Moves With Nearby Elements: no
Dimensions - Area: 0.0320455 m2; Volume: 0.00088404 m3
Identity Data - Mark: 12
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm

# IfcValve: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro GLT_INT-EN:SpiroPure Pro 23.0 GLT, M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro GLT_INT-EN:SpiroPure Pro 23.0 GLT:2040806
In: F00
Type - Material: Color RGB 000-128-255, Color RGB 168-128-048, Color RGB 200-200-200, Color RGB 200-000-000, Color RGB 055-055-055, Color RGB 150-150-150, Color RGB 229-190-001
Type - Other - Category: Pipe Accessories; b: 618.463 mm; Bottom Offset: 145 mm; d: 136.5 mm; Family Name: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro GLT_INT-EN; h: 615 mm; Tank Radius: 132 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 273 mm; Height: 682 mm; Use Nominal Diameter: yes; Water Inlet Connection Diameter: 19 mm; Water Outlet Connection Diameter: 19 mm; Width: 696 mm
Type - Electrical - Phase: 1; Power Supply LED: Battery - CR2450; Voltage: 230 V
Type - Identity Data - Article Description: Build-in demineralization unit - cap. 3420 ltr - Fillcombi - LED Controler; Article Type: SpiroPure Pro 23.0 GLT; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: ©Trimble Europe BV; Custom: no; Description: Build-in demineralization unit - cap. 3420 ltr - Fillcombi - LED Controler; EMCS Version: 5.0; ETIM Article Class: EC011325; Family Version: 24.10; GLN: 8717811000007; GTIN: 8717811064573; Manufacturer: Spirotech; Manufacturer Art. No.: G76.358; Manufacturer URL: https://www.spirotech.com/8717811064573; MEPcontent Class: FILTER; Model: SpiroPure Pro 23.0 GLT; OmniClass Number: 23.75.50.11.14; OmniClass Title: Feedwater Equipment; Product Line: Spirotech; Revit Version: 2023; Type Name: SpiroPure Pro 23.0 GLT; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Brass: Color RGB 168-128-048; Grey: Color RGB 150-150-150; White: Color RGB 200-200-200; Yellow: Color RGB 229-190-001
Type - Mechanical - Max Filling Capacity: 3.42 m3; Resin Volume: 0.023 m3; Weight: 26.7 kg; Working Pressure: 1.5 to 8 bar; Working Temperature: 5 to 40°C
Type - Mechanical - Flow - Max Flow: 0.000333333 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: SpiroPure Pro 23.0 GLT; sets with these values: 2
Other - Back Clearance Safe: 0 mm; Bottom Clearance Safe: 0 mm; Family: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro GLT_INT-EN; Family and Type: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro GLT_INT-EN: SpiroPure Pro 23.0 GLT; Front Clearance Safe: 0 mm; Left Clearance Safe: 0 mm; Right Clearance Safe: 0 mm; Top Clearance Safe: 240 mm; Type: SpiroPure Pro 23.0 GLT; Type Id: 2040788
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 1.52724 m2; Maximum Size: 19 mm; Minimum Size: 19 mm; Volume: 0.0343585 m3
Electrical - Power: 0 W
Identity Data - Mark: 11
Mechanical - System Classification: Undefined,Power
Mechanical - Flow - Water Inlet Connection Flow: 0 m3/s; Water Outlet Connection Flow: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Back Clearance: 0 mm; Bottom Clearance: 0 mm; Front Clearance: 0 mm; Left Clearance: 0 mm; Right Clearance: 0 mm; Show Service Area: no; Top Clearance: 240 mm
Insulation - Insulation Thickness: 0 mm
